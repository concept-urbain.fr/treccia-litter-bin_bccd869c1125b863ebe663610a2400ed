Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Corbeille Treccia.IFC
Time: 2023-07-26T07:50:22
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 101222_Default
In: Default Storey
Material: PE

# IfcBuildingElementProxy: 104660_Default (2)
In: Default Storey
Name
104660_Default | PSet_Mass_Property - Mass Measure: 73.0399; Area Measure: 6.84923 m2; Volume Measure: 0.0105194 m3
104660_Default
